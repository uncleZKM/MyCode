# Keil uVision project test.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_MD
  c include: .\SYSTEM\delay;.\SYSTEM\sys;.\SYSTEM\usart;.\HARDWARE\LED;.\HARDWARE\CS1237;.\HARDWARE\OLED;.\HARDWARE\IIC;.\HARDWARE\HX711;.\HARDWARE\DHT11
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./USER/: startup_stm32f10x_md.s
    ./: test.c
  group SYSTEM
    ./SYSTEM/delay/: delay.c
    ./SYSTEM/sys/: sys.c
    ./SYSTEM/usart/: usart.c
  group HARDWARE
    ./HARDWARE/LED/: led.c
    ./HARDWARE/OLED/: oled.c
    ./HARDWARE/IIC/: myiic.c
    ./HARDWARE/DHT11/: dht11.c
